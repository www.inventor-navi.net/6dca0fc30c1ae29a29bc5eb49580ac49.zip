# Autodesk Inventor assembly: アームｖｏｌ2
## iProperties
Created: 2008-02
Part Number: アームｖｏｌ2
Document SubType Name: Assembly
Designer: y-shimazaki
Author: y-shimazaki
