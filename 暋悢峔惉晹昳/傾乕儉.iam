# Autodesk Inventor assembly: アーム
## iProperties
Created: 2008-02
Part Number: アーム
Document SubType Name: Assembly
Designer: y-shimazaki
Author: y-shimazaki
